RDEPENDS:pulseaudio-server:append:beluga = " pulseaudio-modules-droid "
RDEPENDS:pulseaudio-server:append:firefish = " pulseaudio-modules-droid "
