RDEPENDS:${PN}:append:beluga = " qt5-qpa-hwcomposer-plugin "
RDEPENDS:${PN}:append:firefish = " qt5-qpa-hwcomposer-plugin "
