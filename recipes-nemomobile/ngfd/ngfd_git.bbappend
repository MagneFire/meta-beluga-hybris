RDEPENDS:${PN}:append:beluga = " ngfd-plugin-droid-vibrator "
RDEPENDS:${PN}:append:firefish = " ngfd-plugin-droid-vibrator "
