RDEPENDS:${PN}:append:beluga = " geoclue-provider-hybris "
RDEPENDS:${PN}:append:firefish = " geoclue-provider-hybris "
