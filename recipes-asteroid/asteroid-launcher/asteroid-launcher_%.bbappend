FILESEXTRAPATHS:prepend:beluga := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:beluga = " file://default.conf"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:firefish = " file://default.conf"
